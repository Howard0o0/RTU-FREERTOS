# IAR project RTOSDemo.ewp, settings and files
configuration Debug_Large_Data_Model (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430xllff.h
  General.OGChipSelectMenu: MSP430F5438A MSP430F5438A
  General.GStackSize2: 512
  General.GHeapSize2: 2048
  General.RadioHeapSizeType: 0
  ICC430.CCDiagSuppress: Pa082
  ICC430.newCCIncludePaths: F5XX_6XX_Core_Lib; MSP-EXP430F5438_HAL; UserExperienceDemo; Common\include; Source\include; Source\portable\IAR\MSP430X; $PROJ_DIR$; Apps\include; Drivers; Driverlib; Oldproject
  ICC430.CCOptLevel: 0
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  A430.AUserIncludes: $PROJ_DIR$; Source\portable\IAR\MSP430X
  XLINK.XclFile: $TOOLKIT_DIR$\config\linker\lnk430f5438a.xcl
  XLINK.XlinkStackSize: 1
configuration Release_Large_Data_Model (MSP430, debug)
  as the first configuration, except:
  General.GStackSize2: 160
  General.GHeapSize2: 160
  ICC430.newCCIncludePaths: F5XX_6XX_Core_Lib; MSP-EXP430F5438_HAL; UserExperienceDemo; ..\Common\include; ..\..\Source\include; ..\..\Source\portable\IAR\MSP430X; $PROJ_DIR$
  ICC430.CCOptLevel: 3
  A430.AUserIncludes: $PROJ_DIR$; ..\..\Source\portable\IAR\MSP430X
  XLINK.XclFile: lnk430F5438A_mod.xcl
configuration Debug_Small_Data_Model (MSP430, debug)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430xlsff.h
  General.GStackSize2: 160
  General.GHeapSize2: 160
  ICC430.newCCIncludePaths: as above
  A430.AUserIncludes: $PROJ_DIR$; ..\..\Source\portable\IAR\MSP430X
  XLINK.XclFile: lnk430F5438A_mod.xcl
configuration Debug_Medium_Data_Model (MSP430, debug)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430xlmff.h
  General.GStackSize2: 160
  General.GHeapSize2: 4
  ICC430.newCCIncludePaths: as above
  A430.AUserIncludes: $PROJ_DIR$; ..\..\Source\portable\IAR\MSP430X
  XLINK.XclFile: lnk430F5438A_mod.xcl
  group (top)
    ./: boot.c boot.h lnk430F5438A_mod.xcl low_level_init.c main.c module_config.h ParTest.c RunTimeStatsConfig.c serial.c
  group Apps
    Apps/: BLE_Task.c communication_opr.c Hydrolody_Task.c memoryleakcheck.c RTC_Task.c
  group Apps/include
    Apps/include/: BLE_Task.h communication_opr.h Hydrolody_Task.h memoryleakcheck.h RTC_Task.h
  group Common
    Common/Minimal/: comtest.c dynamic.c GenQTest.c
  group Driverlib
    Driverlib/: adc10_a.c adc10_a.h adc12_a.c adc12_a.h aes.c aes.h battbak.c battbak.h comp_b.c comp_b.h crc.c crc.h ctsd16.c ctsd16.h dac12_a.c dac12_a.h dma.c dma.h driverlib.h eusci_a_spi.c eusci_a_spi.h eusci_a_uart.c eusci_a_uart.h eusci_b_i2c.c eusci_b_i2c.h eusci_b_spi.c eusci_b_spi.h flashctl.c flashctl.h gpio.c gpio.h lcd_b.c lcd_b.h lcd_c.c lcd_c.h ldopwr.c ldopwr.h mpy32.c mpy32.h oa.c oa.h pmap.c pmap.h pmm.c pmm.h ram.c ram.h ref.c ref.h rtc_a.c rtc_a.h rtc_b.c rtc_b.h rtc_c.c rtc_c.h sd24_b.c sd24_b.h sfr.c sfr.h sysctl.c sysctl.h tec.c tec.h timer_a.c timer_a.h timer_b.c timer_b.h timer_d.c timer_d.h tlv.c tlv.h ucs.c ucs.h usci_a_spi.c usci_a_spi.h usci_a_uart.c usci_a_uart.h usci_b_i2c.c usci_b_i2c.h usci_b_spi.c usci_b_spi.h wdt_a.c wdt_a.h
  group Driverlib/inc
    Driverlib/inc/: hw_memmap.h version.h
  group Drivers
    Drivers/: gprs.c gprs.h
  group F5XX_6XX_Core_Lib
    F5XX_6XX_Core_Lib/: HAL_PMM.c hal_UCS.c
  group MSP-EXP430F5438_HAL
    MSP-EXP430F5438_HAL/: hal_board.c hal_buttons.c hal_lcd.c hal_lcd_fonts.c hal_MSP-EXP430F5438.h
  group Oldproject
    Oldproject/: adc.c adc.h BC95.c BC95.h blueTooth.c blueTooth.h common.c common.h Console.c Console.h debug.c debug.h dtu.c dtu.h flash.c flash.h flow.c flow.h hydrologycommand.c hydrologycommand.h hydrologytask.c hydrologytask.h ioDev.c ioDev.h led.c led.h main.h message.c message.h msp430common.h packet.c packet.h reportbinding .c reportbinding.h rom.c rom.h rtc.c rtc.h Sampler.c Sampler.h store.c store.h timer.c timer.h uart0.c uart0.h uart1.c uart1.h uart2.c uart2.h uart3.c uart3.h uart_config.c uart_config.h wifi_config.c wifi_config.h
  group Source
    Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group Source/Portable
    Source/portable/MemMang/: heap_4.c
    Source/portable/IAR/MSP430X/: port.c portext.s43
