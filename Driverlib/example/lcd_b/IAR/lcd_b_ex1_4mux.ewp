# IAR project lcd_b_ex1_4mux.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430xsfn.h
  General.OGChipSelectMenu: MSP430FG6626 MSP430FG6626
  General.GStackSize2: 80
  General.GHeapSize2: 80
  General.RadioHeapSizeType: 0
  ICC430.newCCIncludePaths: ../../../../driverlib/MSP430F5xx_6xx; ../..
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430FR5969.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  ICC430.CCDefines: DEPRECATED
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 1
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F149.xcl
  group (top)
    ../: lcd_b_ex1_4mux.c
  group driverlib/MSP430F5xx_6xx
    ../../../../driverlib/MSP430F5xx_6xx/: comp_b.c eusci_a_uart.c lcd_c.c adc10_a.c sysctl.h dma.c dma.h eusci_b_i2c.h rtc_b.h timer_d.c crc.h ram.c usci_a_uart.h rtc_c.c flashctl.h ram.h dac12_a.h pmap.h tlv.c dac12_a.c mpy32.h rtc_a.h ucs.h aes.h timer_b.c eusci_b_spi.c ctsd16.c pmap.c ucs.c sd24_b.c tec.h usci_a_spi.h usci_a_uart.c crc.c eusci_a_spi.c sfr.h wdt_a.h timer_a.h oa.h pmm.h adc12_a.c ldopwr.c lcd_b.h usci_b_spi.c rtc_c.h adc10_a.h sfr.c wdt_a.c tec.c eusci_a_uart.h ctsd16.h battbak.c usci_b_spi.h driverlib.h comp_b.h gpio.h usci_b_i2c.c rtc_a.c mpy32.c tlv.h eusci_b_i2c.c rtc_b.c usci_a_spi.c gpio.c ldopwr.h adc12_a.h ref.h eusci_a_spi.h timer_b.h battbak.h oa.c pmm.c aes.c usci_b_i2c.h ref.c eusci_b_spi.h timer_d.h lcd_b.c sysctl.c lcd_c.h timer_a.c sd24_b.h flashctl.c
  group driverlib/MSP430F5xx_6xx/inc
    ../../../../driverlib/MSP430F5xx_6xx/inc/: hw_memmap.h version.h
